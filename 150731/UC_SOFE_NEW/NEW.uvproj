# Keil uVision project NEW.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82FE564 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: NEWPRO_610 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group FILES
    ./: main.c LED.C AD3421.C EEPROM.C DAC6571_mV.C DAC6571_mA.C TYPE_SLOPE.c MCP79411.C
