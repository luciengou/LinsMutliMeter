# Keil uVision project TC_PROUCT.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: TC_PRODUCT +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c LED.C MCP4011.c Counter.C EEPROM.C TYPE_SLOPE.c AD111.C
