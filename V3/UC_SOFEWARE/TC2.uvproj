# Keil uVision project TC2.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: TC2 +hex
  c flags: Optimize=4 SizeSpeed=1
  link misc: REMOVEUNUSED
  group FILES
    ./: main.c LED.C EEPROM.C RTC3130.C AD3421.C DAC6571_mV.C DAC6571_mA.C TYPE_SLOPE.c
